# Keil uVision project mh1903.uvprojx, settings and files
target mh1903_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: mh1903 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\output\@L.bin !L
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE,NDEBUG,CONFIG_USB_DEVICE_MSC
  c include: ..\mh1903_lib\Device\MegaHunt\mhscpu\Include;..\mh1903_lib\CMSIS\Include;..\mh1903_lib\MHSCPU_Driver\inc;..\core;..\FreeRTOS\Source\include;..\FreeRTOS;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS\CMSIS_RTOS_V2;..\app;..\mid\ram;..\mid\msg;..\mid\log;..\tasks;..\app;..\driver;..\lvgl;..\lvgl\src;..\lvgl\src\core;..\lvgl\src\draw;..\lvgl\src\extra;..\lvgl\src\font;..\lvgl\src\hal;..\lvgl\src\misc;..\lvgl\src\widgets;..\cm_backtrace;..\crypto;..\ui\lv_demos;..\ui\pillar_demos;..\mid\fatfs;..\mid\param;..\cryption\ur;..\mid\checksum;..\mid\cbor;..\cryption\secp256k1;..\mid\utils;..\driver\usb;..\mh1903_lib\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\msc\inc;..\mh1903_lib\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;..\mh1903_lib\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;..\mh1903_lib\USB-ESL;..\mid\quicklz;..\mid\param\cjson;..\mh1903_lib\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\cdc\inc;..\mid\ram;..\mid\reduced_gl;..\mh1903_lib\MHSCPU_Driver\inc\cryptlib;..\external\ctaes
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x100000
  group core
    ../core/: main.c mhscpu_conf.h assert.c
  group app
    ../app/: firmware_update.c draw_on_lcd.c lv_font.c openSans_20.c lv_font_fmt_txt.c lv_utils.c openSans_24.c check_app.c recovery_mode.c
  group mid
    ../mid/log/: log_print.c
    ../mid/fatfs/: diskio.c ff.c user_fatfs.c ffunicode.c
    ../mid/param/cjson/: cJSON.c
    ../mid/checksum/: crc.c
    ../mid/utils/: user_utils.c user_delay.c
    ../mid/quicklz/: quicklz.c
    ../mid/ram/: heap_4.c
    ../mid/reduced_gl/: reduced_gl.c
  group driver
    ../driver/: drv_uart.c drv_sys.c drv_spi.c drv_trng.c drv_nt35510.c drv_ds28s60.c drv_gd25qxx.c drv_sdcard.c drv_rtc.c drv_battery.c drv_qspi_flash.c drv_lcd_bright.c drv_power.c drv_ili9806.c hal_lcd.c hardware_version.c drv_parallel8080.c drv_i2c_io.c hal_touch.c drv_cst726.c drv_ft6336.c drv_cst3xx.c drv_i2c.c drv_gsl1691.c drv_aw32001.c drv_spi_io.c drv_otp.c drv_sdio.c
  group driver/usb
    ../driver/usb/: drv_usb.c usb_bsp.c usbd_composite.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbd_cdc_vcp.c
    ../mh1903_lib/SCPU_USB_Lib/SCPU_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../mh1903_lib/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../mh1903_lib/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../mh1903_lib/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../mh1903_lib/USB-ESL/: CircularBuffer.c
  group cm_backtrace
    ../cm_backtrace/: cm_backtrace.c
    ../cm_backtrace/fault_handler/keil/: cmb_fault.S
  group mh1903_driver
    ../mh1903_lib/MHSCPU_Driver/src/: misc.c mhscpu_exti.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_uart.c mhscpu_spi.c mhscpu_rtc.c mhscpu_dma.c mhscpu_psram.c mhscpu_trng.c mhscpu_lcdi.c mhscpu_i2c.c mhscpu_timer.c mhscpu_sdio.c mhscpu_ssc.c mhscpu_adc.c mhscpu_qspi.c mhscpu_otp.c mh_rand.c mhscpu_cache.c
  group mdk
    ../mh1903_lib/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group cmsis
    ../mh1903_lib/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group crypto
    ../crypto/: sha256.c sha256_hmac.c
  group libs
    ../mh1903_lib/MHSCPU_Driver/lib/: crypt_s_lib.lib
  group external
    ../external/ctaes/: ctaes.c
software components: CMSIS:CORE 5.6.0
